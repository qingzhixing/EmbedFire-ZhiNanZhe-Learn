# Keil uVision project EmbedFire-F103-Project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EmbedFire-F103-Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s main.c
    ./lib/: stm32f10x.h bit.h stdint.h stm32f10x_gpio.c stm32f10x_gpio.h
